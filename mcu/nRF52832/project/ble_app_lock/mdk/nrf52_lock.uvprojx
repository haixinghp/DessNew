# Keil uVision project nrf52_lock.uvprojx, settings and files
target 52832_LOCK (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.16.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: emb +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: CONFIG_NFCT_PINS_AS_GPIOS FLOAT_ABI_HARD NRF52 NRF52832_XXAA NRF52_PAN_74 NRF_SD_BLE_API_VERSION=6 S112 SOFTDEVICE_PRESENT SWI_DISABLE0 __HEAP_SIZE=8192 __STACK_SIZE=8192
  c misc: --reduce_paths
  c include: ..\..\..\config;..\..\..\components;..\..\..\components\ble\ble_advertising;..\..\..\components\ble\ble_link_ctx_manager;..\..\..\components\ble\ble_racp;..\..\..\components\ble\ble_services\ble_nus;..\..\..\components\ble\common;..\..\..\components\ble\nrf_ble_gatt;..\..\..\components\ble\nrf_ble_qwr;..\..\..\components\ble\peer_manager;..\..\..\components\boards;..\..\..\components\drivers_nrf\usbd;..\..\..\components\libraries\atomic;..\..\..\components\libraries\atomic_fifo;..\..\..\components\libraries\atomic_flags;..\..\..\components\libraries\balloc;..\..\..\components\libraries\bootloader\ble_dfu;..\..\..\components\libraries\bsp;..\..\..\components\libraries\button;..\..\..\components\libraries\cli;..\..\..\components\libraries\crc16;..\..\..\components\libraries\crc32;..\..\..\components\libraries\crypto;..\..\..\components\libraries\csense;..\..\..\components\libraries\csense_drv;..\..\..\components\libraries\delay;..\..\..\components\libraries\ecc;..\..\..\components\libraries\experimental_log;..\..\..\components\libraries\experimental_log\src;..\..\..\components\libraries\experimental_memobj;..\..\..\components\libraries\experimental_mpu;..\..\..\components\libraries\experimental_ringbuf;..\..\..\components\libraries\experimental_section_vars;..\..\..\components\libraries\experimental_stack_guard;..\..\..\components\libraries\experimental_task_manager;..\..\..\components\libraries\fds;..\..\..\components\libraries\fifo;..\..\..\components\libraries\fstorage;..\..\..\components\libraries\gfx;..\..\..\components\libraries\gpiote;..\..\..\components\libraries\hardfault;..\..\..\components\libraries\hci;..\..\..\components\libraries\led_softblink;..\..\..\components\libraries\low_power_pwm;..\..\..\components\libraries\mem_manager;..\..\..\components\libraries\mutex;..\..\..\components\libraries\pwm;..\..\..\components\libraries\pwr_mgmt;..\..\..\components\libraries\queue;..\..\..\components\libraries\scheduler;..\..\..\components\libraries\sdcard;..\..\..\components\libraries\slip;..\..\..\components\libraries\sortlist;..\..\..\components\libraries\spi_mngr;..\..\..\components\libraries\strerror;..\..\..\components\libraries\timer;..\..\..\components\libraries\twi_mngr;..\..\..\components\libraries\twi_sensor;..\..\..\components\libraries\uart;..\..\..\components\libraries\usbd;..\..\..\components\libraries\usbd\class\audio;..\..\..\components\libraries\usbd\class\cdc;..\..\..\components\libraries\usbd\class\cdc\acm;..\..\..\components\libraries\usbd\class\hid;..\..\..\components\libraries\usbd\class\hid\generic;..\..\..\components\libraries\usbd\class\hid\kbd;..\..\..\components\libraries\usbd\class\hid\mouse;..\..\..\components\libraries\usbd\class\msc;..\..\..\components\libraries\usbd\config;..\..\..\components\libraries\util;..\..\..\components\softdevice\common;..\..\..\components\softdevice\s132\headers;..\..\..\components\softdevice\s132\headers\nrf52;..\..\..\external\fprintf;..\..\..\external\segger_rtt;..\..\..\integration\nrfx;..\..\..\integration\nrfx\legacy;..\..\..\modules\nrfx;..\..\..\modules\nrfx\drivers\include;..\..\..\modules\nrfx\hal;..\..\..\modules\nrfx\mdk;..\..\..\components\libraries\simple_timer;..\..\..\integration\nrfx\legacy;..\..\..\..\..\emb\ID2;..\..\..\..\..\emb\ble_app_lock;..\..\..\..\..\emb\Public;..\..\..\..\..\emb\DRV;..\..\..\..\..\emb\HAL;..\..\..\..\..\emb\APP;..\..\..\..\..\emb\Scheduler;..\..\..\..\..\emb\System;..\..\..\..\..\emb\ISR;..\..\..\..\..\emb\HW;..\..\..\..\..\emb\HW\nRF52832;..\..\..\..\..\emb\ID2\NXP;..\..\..\..\..\emb\System\nRF52832_System;..\..\..\..\..\emb\DRV\DRV_ADC\nRF52832_ADC;..\..\..\..\..\emb\DRV\DRV_BLE\nRF52832_BLE;..\..\..\..\..\emb\DRV\DRV_GPIO\nRF52832_GPIO;..\..\..\..\..\emb\DRV\DRV_UART\nRF52832_UART;..\..\..\..\..\emb\DRV\DRV_API\nRF52832;..\..\..\..\..\emb\DRV\DRV_CLK\nRF52832_CLK;..\..\..\..\..\emb\DRV\DRV_TIMER\nRF52832_TIMER;..\..\..\..\..\emb\APP\APP_GUI\fully_auto;..\..\..\..\..\emb\System\SystemInit\fully_auto
  asm define: FLOAT_ABI_HARD NRF52 NRF52832_XXAA NRF52_PAN_74 NRF_SD_BLE_API_VERSION=6 S112 SOFTDEVICE_PRESENT SWI_DISABLE0 __HEAP_SIZE=8192 __STACK_SIZE=8192
  asm misc: --cpreproc_opts=-DBOARD_PCA10040,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DNRF52,-DNRF52832_XXAA,-DNRF52_PAN_74,-DNRF_SD_BLE_API_VERSION=6,-DS132,-DSOFTDEVICE_PRESENT,-DSWI_DISABLE0,-D__HEAP_SIZE=8192,-D__STACK_SIZE=8192
  asm include: ..\..\..\config;..\..\..\components;..\..\..\components\ble\ble_advertising;..\..\..\components\ble\ble_link_ctx_manager;..\..\..\components\ble\ble_racp;..\..\..\components\ble\ble_services\ble_nus;..\..\..\components\ble\common;..\..\..\components\ble\nrf_ble_gatt;..\..\..\components\ble\nrf_ble_qwr;..\..\..\components\ble\peer_manager;..\..\..\components\boards;..\..\..\components\drivers_nrf\usbd;..\..\..\components\libraries\atomic;..\..\..\components\libraries\atomic_fifo;..\..\..\components\libraries\atomic_flags;..\..\..\components\libraries\balloc;..\..\..\components\libraries\bootloader\ble_dfu;..\..\..\components\libraries\bsp;..\..\..\components\libraries\button;..\..\..\components\libraries\cli;..\..\..\components\libraries\crc16;..\..\..\components\libraries\crc32;..\..\..\components\libraries\crypto;..\..\..\components\libraries\csense;..\..\..\components\libraries\csense_drv;..\..\..\components\libraries\delay;..\..\..\components\libraries\ecc;..\..\..\components\libraries\experimental_log;..\..\..\components\libraries\experimental_log\src;..\..\..\components\libraries\experimental_memobj;..\..\..\components\libraries\experimental_mpu;..\..\..\components\libraries\experimental_ringbuf;..\..\..\components\libraries\experimental_section_vars;..\..\..\components\libraries\experimental_stack_guard;..\..\..\components\libraries\experimental_task_manager;..\..\..\components\libraries\fds;..\..\..\components\libraries\fifo;..\..\..\components\libraries\fstorage;..\..\..\components\libraries\gfx;..\..\..\components\libraries\gpiote;..\..\..\components\libraries\hardfault;..\..\..\components\libraries\hci;..\..\..\components\libraries\led_softblink;..\..\..\components\libraries\low_power_pwm;..\..\..\components\libraries\mem_manager;..\..\..\components\libraries\mutex;..\..\..\components\libraries\pwm;..\..\..\components\libraries\pwr_mgmt;..\..\..\components\libraries\queue;..\..\..\components\libraries\scheduler;..\..\..\components\libraries\sdcard;..\..\..\components\libraries\slip;..\..\..\components\libraries\sortlist;..\..\..\components\libraries\spi_mngr;..\..\..\components\libraries\strerror;..\..\..\components\libraries\timer;..\..\..\components\libraries\twi_mngr;..\..\..\components\libraries\twi_sensor;..\..\..\components\libraries\uart;..\..\..\components\libraries\usbd;..\..\..\components\libraries\usbd\class\audio;..\..\..\components\libraries\usbd\class\cdc;..\..\..\components\libraries\usbd\class\cdc\acm;..\..\..\components\libraries\usbd\class\hid;..\..\..\components\libraries\usbd\class\hid\generic;..\..\..\components\libraries\usbd\class\hid\kbd;..\..\..\components\libraries\usbd\class\hid\mouse;..\..\..\components\libraries\usbd\class\msc;..\..\..\components\libraries\usbd\config;..\..\..\components\libraries\util;..\..\..\components\softdevice\common;..\..\..\components\softdevice\s132\headers;..\..\..\components\softdevice\s132\headers\nrf52;..\..\..\external\fprintf;..\..\..\external\segger_rtt;..\..\..\integration\nrfx;..\..\..\integration\nrfx\legacy;..\..\..\modules\nrfx;..\..\..\modules\nrfx\drivers\include;..\..\..\modules\nrfx\hal;..\..\..\modules\nrfx\mdk;..\..\..\components\libraries\simple_timer;..\..\..\integration\nrfx\legacy
  library: MicroLIB
  memory RVCT4: ROM 0x19000 size 0x5a000
  memory RVCT9: RAM 0x20002a98 size 0xc568
  memory RVCT10: RAM 0x2000f000 size 0x1000
  link misc: --diag_suppress 6330
  group Main
    ../../../../../: main.c
    ../../../../../emb/System/: LockConfig.h SystemTim.c
    ../../../../../emb/System/nRF52832_System/: PlatformFunc.c
    ../../../config/: sdk_config.h
    ../../../../../emb/System/SystemInit/fully_auto/: SystemInit.c
  group Scheduler
    ../../../../../emb/Scheduler/: Scheduler.c Scheduler.h
  group ISR
    ../../../../../emb/ISR/: ISR.c ISR.h
  group APP
    ../../../../../emb/APP/: System.c App_IR.c APP_ID2.c App_Key.c App_LED.c App_PWD.c APP_BLE.c APP_CAM.c App_WIFI.c App_Touch.c App_Export.c App_Finger.c App_Screen.c App_Update.c APP_SmartKey.c APP_FACE.c APP_FACE_PRO.c App_HumanSensor.c App_NB.c
    ../../../../../emb/APP/APP_GUI/fully_auto/: App_GUI.c
  group Server
    ../../../../../emb/Server/: Finger.c Face.c Screen.c
  group LockHal
    ../../../../../emb/HAL/HAL_RTC/: HAL_RTC.c
    ../../../../../emb/HAL/HAL_ADC/: HAL_ADC.c
    ../../../../../emb/HAL/HAL_UART/: HAL_UART.c
    ../../../../../emb/HAL/HAL_VOICE/: HAL_Voice.c
    ../../../../../emb/HAL/HAL_Motor/: HAL_Motor.c
    ../../../../../emb/HAL/HAL_Touch/: HAL_Touch.c
    ../../../../../emb/HAL/HAL_EXPORT/: HAL_EXPORT.c
    ../../../../../emb/HAL/HAL_EEPROM/: HAL_EEPROM.c
  group LockDrv
    ../../../../../emb/DRV/DRV_IIC/: DRV_IIC.c
    ../../../../../emb/DRV/DRV_ADC/nRF52832_ADC/: DRV_ADC.c
    ../../../../../emb/DRV/DRV_BLE/nRF52832_BLE/: DRV_BLE.c
    ../../../../../emb/DRV/DRV_CLK/nRF52832_CLK/: DRV_CLK.c
    ../../../../../emb/DRV/DRV_GPIO/nRF52832_GPIO/: DRV_GPIO.c
    ../../../../../emb/DRV/DRV_UART/nRF52832_UART/: DRV_UART.c
    ../../../../../emb/DRV/DRV_TIMER/nRF52832_TIMER/: DRV_TIMER.c
    ../../../../../emb/DRV/DRV_Motor/: DRV_Motor.c DRV_Motor_216.c DRV_Motor_218.c
    ../../../../../emb/DRV/DRV_Radar/: DRV_Radar.c
    ../../../../../emb/DRV/DRV_API/nRF52832/: DRV_Interface.c
    ../../../../../emb/DRV/DRV_TOUCH/: DRV_GT316L.c
    ../../../../../emb/DRV/DRV_EXPORT/: DRV_MIB5024.c DRV_NCA9555.c DRV_74HC4052.c
    ../../../../../emb/DRV/DRV_VOICE/: DRV_AM5BA340.c
    ../../../../../emb/DRV/DRV_EEPROM/: DRV_HE24C512.c
    ../../../../../emb/DRV/DRV_RTC/: DRV_RTC_BM8563.c
  group LockPublic
    ../../../../../emb/Public/: Public.c Md5.c Rijndael.c Encrypto.c app_fifo.c
  group ID2
    ../../../../../emb/ID2/NXP/: sci2c.c scp.c sm_apdu.c smCom.c smComSCI2C.c
    ../../../../../emb/ID2/: api_hash.c api_init.c api_rand.c api_sm4.c base64.c chip_log.c id2_client.c id2_plat.c id2_util.c km_to_irot.c ls_hal_hash.c ls_hal_rand.c ls_osa.c md5.c mtk_se_adapter.c otp.c se_driver.c se_timer.c sha1.c sha256.c std_se_adapter.c
  group nRF_BLE
    ../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../../../components/ble/ble_advertising/: ble_advertising.c
    ../../../components/ble/ble_link_ctx_manager/: ble_link_ctx_manager.c
    ../../../components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
    ../../../components/ble/nrf_ble_qwr/: nrf_ble_qwr.c
  group nRF_BLE_Services
    ../../../components/ble/ble_services/ble_nus/: ble_nus.c
  group nRF_Drivers
    ../../../integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_uart.c nrf_drv_rng.c
    ../../../modules/nrfx/drivers/src/: nrfx_clock.c nrfx_gpiote.c nrfx_power_clock.c nrfx_uart.c nrfx_uarte.c nrfx_saadc.c nrfx_timer.c nrfx_rng.c
    ../../../modules/nrfx/drivers/src/prs/: nrfx_prs.c
  group nRF_Libraries
    ../../../components/libraries/button/: app_button.c
    ../../../components/libraries/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../components/libraries/scheduler/: app_scheduler.c
    ../../../components/libraries/timer/: app_timer.c
    ../../../components/libraries/uart/: app_uart_fifo.c retarget.c
    ../../../components/libraries/hardfault/: hardfault_implementation.c
    ../../../components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../../components/libraries/atomic_flags/: nrf_atflags.c
    ../../../components/libraries/atomic/: nrf_atomic.c
    ../../../components/libraries/balloc/: nrf_balloc.c
    ../../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_sd.c
    ../../../components/libraries/experimental_memobj/: nrf_memobj.c
    ../../../components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../../../components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../../components/libraries/strerror/: nrf_strerror.c
    ../../../components/libraries/simple_timer/: app_simple_timer.c
    ../../../components/libraries/queue/: nrf_queue.c
  group nRF_Log
    ../../../components/libraries/experimental_log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Segger_RTT
    ../../../external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT_Syscalls_KEIL.c
  group nRF_SoftDevice
    ../../../components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.16.0
