# Keil uVision project peripheral.uvprojx, settings and files
target ble_peripheral (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: app
  BeforeMake: ..\..\..\tool\before_build_common.bat $K
  BeforeMake: before_build_special.bat
  AfterMake: ..\..\..\tool\after_build_common.bat $J #L @L
  AfterMake: after_build_special.bat
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --gnu --preinclude app_flags.h --bss_threshold=0
  c include: ..\..\..\inc\app;..\..\..\inc\bluetooth\gap;..\..\..\inc\bluetooth\gap\gap_lib;..\..\..\inc\bluetooth\profile;..\..\..\inc\bluetooth\profile\server;..\..\..\inc\bluetooth\profile\client;..\..\..\inc\os;..\..\..\inc\peripheral;..\..\..\inc\platform;..\..\..\inc\platform\cmsis;..\..\..\src\sample\ble_peripheral;..\ble_peripheral;..\ble_app_lock;..\..\..\..\..\emb\ID2;..\..\..\..\..\emb\Public;..\..\..\..\..\emb\DRV;..\..\..\..\..\emb\HAL;..\..\..\..\..\emb\APP;..\..\..\..\..\emb\Scheduler;..\..\..\..\..\emb\System;..\..\..\..\..\emb\ISR;..\..\..\..\..\emb\HW;..\..\..\..\..\emb\HW\RTL8762;..\..\..\..\..\emb\ID2\NXP;..\..\..\..\..\3rdParty;..\..\..\..\..\emb\System\RTL8762_System;..\..\..\..\..\emb\DRV\DRV_ADC\RTL8762_ADC;..\..\..\..\..\emb\DRV\DRV_BLE\RTL8762_BLE;..\..\..\..\..\emb\DRV\DRV_GPIO\RTL8762_GPIO;..\..\..\..\..\emb\DRV\DRV_UART\RTL8762_UART;..\..\..\..\..\emb\DRV\DRV_API\RTL8762;..\..\..\..\..\emb\DRV\DRV_TIMER\RTL8762_TIMER;..\..\..\..\..\emb\DRV\DRV_CLK\RTL8762_CLK;..\..\..\..\..\emb\DRV\DRV_EXPORT;..\..\..\..\..\emb\APP\APP_GUI\semi_auto;..\..\..\..\..\emb\System\SystemInit\semi_auto
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\app.sct
  link misc: --diag_suppress=L6314,L6312 --datacompressor off
  group Main
    ../../../src/sample/ble_peripheral/: ancs.c app_task.c main.c
    ../../../src/mcu/rtl876x/: overlay_mgr.c
    ../../../../../emb/System/RTL8762_System/: PlatformFunc.c
    ../../../../../emb/System/: SystemTim.c LockConfig.h
    ../../../../../emb/System/SystemInit/semi_auto/: SystemInit.c
  group Scheduler
    ../../../../../emb/Scheduler/: Scheduler.c
  group ISR
    ../../../../../emb/ISR/: ISR.c
  group APP
    ../../../../../emb/APP/: System.c App_IR.c App_Key.c APP_ID2.c App_LED.c APP_BLE.c APP_CAM.c App_PWD.c App_WIFI.c App_Export.c App_Finger.c App_Radar.c App_Screen.c App_Touch.c App_Update.c APP_SmartKey.c APP_FACE.c APP_FACE_PRO.c App_HumanSensor.c
    ../../../../../emb/APP/APP_GUI/semi_auto/: App_GUI.c
  group Server
    ../../../../../emb/Server/: Face.c Finger.c Screen.c
  group LockHal
    ../../../../../emb/HAL/HAL_ADC/: HAL_ADC.c
    ../../../../../emb/HAL/HAL_RTC/: HAL_RTC.c
    ../../../../../emb/HAL/HAL_UART/: HAL_UART.c
    ../../../../../emb/HAL/HAL_VOICE/: HAL_Voice.c
    ../../../../../emb/HAL/HAL_Motor/: HAL_Motor.c
    ../../../../../emb/HAL/HAL_Touch/: HAL_Touch.c
    ../../../../../emb/HAL/HAL_EXPORT/: HAL_EXPORT.c
    ../../../../../emb/HAL/HAL_EEPROM/: HAL_EEPROM.c
  group LockDrv
    ../../../../../emb/DRV/DRV_IIC/: DRV_IIC.c
    ../../../../../emb/DRV/DRV_CLK/RTL8762_CLK/: DRV_CLK.c
    ../../../../../emb/DRV/DRV_ADC/RTL8762_ADC/: DRV_ADC.c
    ../../../../../emb/DRV/DRV_BLE/RTL8762_BLE/: DRV_BLE.c
    ../../../../../emb/DRV/DRV_UART/RTL8762_UART/: DRV_UART.c
    ../../../../../emb/DRV/DRV_GPIO/RTL8762_GPIO/: DRV_GPIO.c
    ../../../../../emb/DRV/DRV_TIMER/RTL8762_TIMER/: DRV_TIMER.c
    ../../../../../emb/DRV/DRV_Motor/: DRV_Motor.c DRV_Motor_216.c DRV_Motor_218.c
    ../../../../../emb/DRV/DRV_Radar/: DRV_Radar.c
    ../../../../../emb/DRV/DRV_API/RTL8762/: DRV_Interface.c
    ../../../../../emb/DRV/DRV_TOUCH/: DRV_GT316L.c
    ../../../../../emb/DRV/DRV_EXPORT/: DRV_NCA9555.c DRV_74HC4052.c DRV_MIB5024.c
    ../../../../../emb/DRV/DRV_EEPROM/: DRV_HE24C512.c
    ../../../../../emb/DRV/DRV_VOICE/: DRV_AM5BA340.c
    ../../../../../emb/DRV/DRV_RTC/: DRV_RTC_BM8563.c
  group LockPublic
    ../../../../../emb/Public/: Encrypto.c Md5.c Public.c Rijndael.c app_fifo.c
  group ID2
    ../../../../../emb/ID2/: api_hash.c api_init.c api_rand.c api_sm4.c base64.c chip_log.c id2_client.c id2_plat.c id2_util.c km_to_irot.c ls_hal_hash.c ls_hal_rand.c ls_osa.c md5.c mtk_se_adapter.c otp.c se_driver.c se_timer.c sha1.c sha256.c std_se_adapter.c
    ../../../../../emb/ID2/NXP/: sci2c.c scp.c sm_apdu.c smCom.c smComSCI2C.c
  group include
    ../../../inc/platform/: rom_uuid.h app_define.h
  group lib
    ../../../bin/: ROM.lib gap_utils.lib bee2_adc_lib.lib
  group cmsis
    ../../../src/mcu/rtl876x/arm/: startup_rtl8762c.s
    ../../../src/mcu/rtl876x/: system_rtl8762c.c
  group peripheral
    ../../../src/mcu/peripheral/: rtl876x_io_dlps.c rtl876x_rcc.c rtl876x_uart.c rtl876x_gpio.c rtl876x_tim.c rtl876x_adc.c
  group profile
    ../../../src/ble/profile/client/: ancs_client.c
    ../../../src/sample/ble_peripheral/: lock_ble_service.c ota_service.c
