/**
  ******************************************************************************
  * @file    nz_vsprintf.h
  * @author  XK
  * @version V1.0.0
  * @date    02/13/2017
  * @brief
  ******************************************************************************
  */


/* Define to prevent recursive inclusion -------------------------------------*/
#ifndef __NZ_VSPRINTF_H_
#define __NZ_VSPRINTF_H_

#ifdef __cplusplus
 extern "C" {
#endif

/* Includes ------------------------------------------------------------------*/
#include "type.h"


/* Exported constants --------------------------------------------------------*/
/* Exported macro ------------------------------------------------------------*/
/* Exported types ------------------------------------------------------------*/
/* Exported functions ------------------------------------------------------- */

#ifdef __cplusplus
}
#endif

#endif /* __NZ_PRINTF_H_ */

/*************************** (C) COPYRIGHT 2015 XK ************END OF FILE****/

